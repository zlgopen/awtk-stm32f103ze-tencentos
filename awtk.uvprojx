# Keil uVision project awtk.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,HAS_AWTK_CONFIG
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\beep;.\APP\smg;.\APP\key;.\APP\exti;.\APP\time;.\APP\pwm;.\APP\iwdg;.\APP\wwdg;.\APP\input;.\APP\touch_key;.\APP\wkup;.\APP\adc;.\APP\adc_temp;.\APP\dac;.\APP\pwm_dac;.\APP\dma;.\APP\rtc;.\APP\24Cxx;.\APP\iic;.\APP\ds18b20;.\APP\hwjs;.\APP\rs485;.\APP\can;.\APP\tftlcd;.\APP\spi;.\APP\nrf24l01;.\APP\dht11;.\APP\oled;.\APP\RC522;.\APP\Tetris;.\APP\ball;.\APP\touch;.\APP\snake;..\awtk\3rd;..\awtk\src;.\awtk-port;.\TencentOS\arch\arm\arm-v7m\common\include;.\TencentOS\arch\arm\arm-v7m\cortex-m3\armcc;.\TencentOS\kernel\core\include;.\TencentOS\kernel\hal\include;.\TencentOS\kernel\pm\include;.\TencentOS\TOS-CONFIG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: real_main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_can.c stm32f10x_fsmc.c stm32f10x_spi.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group APP
    ./APP/led/: led.c
    ./APP/tftlcd/: tftlcd.c
    ./APP/time/: time.c
    ./APP/key/: key.c
    ./APP/24Cxx/: 24cxx.c
    ./APP/iic/: iic.c
    ./APP/touch/: touch.c
    ./APP/rtc/: rtc.c
    ./APP/spi/: spi.c
  group Public
    ./Public/: system.c usart.c
  group awtk
    ../awtk/src/tkc/: buffer.c color.c color_parser.c compressor.c crc.c darray.c date_time.c easing.c emitter.c event.c event_source.c event_source_fd.c event_source_idle.c event_source_manager.c event_source_manager_default.c event_source_timer.c fscript.c fs.c func_call_parser.c idle_info.c idle_manager.c int_str.c iostream.c istream.c matrix.c mem.c named_value.c object.c object_array.c object_default.c ostream.c path.c rect.c ring_buffer.c rom_fs.c slist.c socket_pair.c str.c str_str.c time_now.c timer_info.c timer_manager.c tokenizer.c utf8.c utils.c value.c value_desc.c wstr.c log.c asset_info.c mutex_nest.c object_locker.c wchar32.c
    ../awtk/src/base/: assets_manager.c bitmap.c canvas.c children_layouter.c children_layouter_factory.c clip_board.c dialog.c dialog_highlighter.c dialog_highlighter_factory.c enums.c event_queue.c events.c font.c font_loader.c font_manager.c glyph_cache.c graphic_buffer.c hscrollable.c idle.c image_base.c image_loader.c image_manager.c input_device_status.c input_engine.c input_method.c layout.c lcd.c lcd_profile.c line_break.c locale_info.c main_loop.c native_window.c self_layouter.c self_layouter_factory.c shortcut.c style.c style_const.c style_factory.c style_mutable.c suggest_words.c system_info.c text_edit.c theme.c timer.c ui_builder.c ui_feedback.c ui_loader.c velocity.c vgcanvas.c widget.c widget_animator.c widget_animator_factory_null.c widget_animator_manager.c widget_factory.c widget_vtable.c window.c window_animator.c window_animator_factory.c window_base.c window_manager.c date_time_format.c asset_loader.c
    ../awtk/src/clip_board/: clip_board_default.c
    ../awtk/src/font_loader/: font_loader_bitmap.c
    ../awtk/src/graphic_buffer/: graphic_buffer_default.c
    ../awtk/src/input_engines/: input_engine_null.c
    ../awtk/src/input_methods/: input_method_creator.c
    ../awtk/src/layouters/: children_layouter_builtins.c children_layouter_parser.c self_layouter_builtins.c self_layouter_default.c self_layouter_menu.c self_layouter_parser.c children_layouter_default.c
    ../awtk/src/main_loop/: main_loop_simple.c
    ../awtk/src/native_window/: native_window_raw.c
    ../awtk/src/ui_loader/: ui_binary_writer.c ui_builder_default.c ui_loader_default.c ui_loader_xml.c ui_serializer.c ui_xml_writer.c window_open.c
    ../awtk/src/vgcanvas/: vgcanvas_null.c
    ../awtk/src/widgets/: app_bar.c button.c button_group.c calibration_win.c check_button.c color_tile.c column.c combo_box.c combo_box_item.c dialog_client.c dialog_helper.c dialog_title.c dragger.c edit.c grid.c grid_item.c group_box.c image.c label.c overlay.c pages.c popup.c progress_bar.c row.c slider.c spin_box.c system_bar.c tab_button.c tab_button_group.c tab_control.c view.c widgets.c digit_clock.c clip_view.c
    ../awtk/src/window_manager/: window_manager_default.c
    ../awtk/src/xml/: xml_builder.c xml_parser.c
    ../awtk/src/: awtk_global.c
    ../awtk/3rd/libunibreak/: emojidef.c graphemebreak.c linebreak.c linebreakdata.c linebreakdef.c unibreakbase.c unibreakdef.c wordbreak.c
    ../awtk/src/blend/: blend_image_bgr565_bgr565.c blend_image_bgr565_bgra8888.c blend_image_bgr565_rgba8888.c blend_image_bgr888_bgr565.c blend_image_bgr888_bgra8888.c blend_image_bgr888_rgba8888.c blend_image_bgra8888_bgr565.c blend_image_bgra8888_bgra8888.c blend_image_bgra8888_rgba8888.c blend_image_rgb565_bgr565.c blend_image_rgb565_bgra8888.c blend_image_rgb565_rgba8888.c blend_image_rgba8888_bgr565.c blend_image_rgba8888_bgra8888.c blend_image_rgba8888_rgba8888.c fill_image_abgr8888.c fill_image_argb8888.c fill_image_bgr565.c fill_image_bgr888.c fill_image_bgra8888.c fill_image_rgb565.c fill_image_rgba8888.c image_g2d.c rotate_image_bgr565.c rotate_image_bgr888.c rotate_image_bgra8888.c rotate_image_rgb565.c rotate_image_rgba8888.c soft_g2d.c stm32_g2d.c blend_image_rgb888_bgr565.c blend_image_rgb888_bgra8888.c blend_image_rgb888_rgba8888.c fill_image_rgb888.c rotate_image_rgb888.c blend_image_bgr565_rgb565.c blend_image_bgr888_bgr888.c blend_image_bgr888_rgb565.c blend_image_bgra8888_rgb565.c blend_image_rgb565_rgb565.c blend_image_rgb888_rgb565.c blend_image_rgb888_rgb888.c blend_image_rgba8888_rgb565.c
  group awtk-port
    ./awtk-port/: lcd_stm32_raw.c main_loop_stm32_raw.c platform.c awtk_config.h assert.c SysTick.c
    ../awtk/src/platforms/raw/: fs_os.c
    ../awtk/src/platforms/tos/: mutex.c rtos.c semaphore.c thread.c
    ../awtk/src/platforms/common/: sys_tick_handler.c
  group awtk-demo
    ../awtk-demo-app/src/: application.c main.c
    ../awtk-demo-app/src/common/: navigator.c navigator.h
    ../awtk-demo-app/src/pages/: home_page.c window1.c window2.c
  group tencentos
    ./TencentOS/arch/arm/arm-v7m/common/: tos_cpu.c tos_fault.c
    ./TencentOS/arch/arm/arm-v7m/cortex-m3/armcc/: port_s.S port_c.c
    ./TencentOS/kernel/core/: tos_event.c tos_global.c tos_mmblk.c tos_mmheap.c tos_mutex.c tos_pend.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c tos_barrier.c tos_binary_heap.c tos_bitmap.c tos_char_fifo.c tos_completion.c tos_countdownlatch.c tos_mail_queue.c tos_message_queue.c tos_priority_mail_queue.c tos_priority_message_queue.c tos_priority_queue.c tos_ring_queue.c tos_rwlock.c tos_stopwatch.c
    ./TencentOS/TOS-CONFIG/: tos_config.h
