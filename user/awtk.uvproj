# Keil uVision project awtk.uvproj, settings and files
target awtk (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: awtk_demo1 +hex
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,NDEBUG,HAS_AWTK_CONFIG
  c include: ..\stm32f10x_fwlib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\user;..\core;..\app\led;..\app\beep;..\app\button;..\app\exti;..\app\iwdg;..\app\wwdg;..\app\tim;..\app\tpad;..\app\lcd;..\app\gui;..\USMART;..\app\rtc;..\app\wkup;..\app\adc;..\app\tsensor;..\app\dac;..\app\dma;..\app\AT24Cxx;..\app\IIC(24C02);..\app\spi;..\app\W25QXX;..\app\rs485;..\app\can;..\app\DS18B20;..\app\DHT11;..\app\adxl345;..\app\nrf24l01;..\app\stm32_flash;..\app\sram;..\app\malloc;..\app\SysTick;..\app\RTC_J;..\app\touch;..\awtk\src;..\awtk\3rd;..\awtk\;..\awtk-port\;..\TencentOS\arch\arm\arm-v7m\cortex-m3\armcc;..\TencentOS\kernel\core\include;..\TencentOS\kernel\hal\include;..\TencentOS\kernel\pm\include;..\TencentOS\TOS-CONFIG;..\TencentOS\arch\arm\arm-v7m\common\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./: stm32f10x_it.c system_stm32f10x.c main.c
  group system
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group core
    ../core/: core_cm3.c startup_stm32f10x_hd.s
  group fwlib
    ../stm32f10x_fwlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_iwdg.c stm32f10x_wwdg.c stm32f10x_tim.c stm32f10x_fsmc.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c
  group app
    ../app/led/: led.c
    ../app/lcd/: lcd_driver.c
    ../app/button/: button.c
    ../app/tim/: tim.c
    ../app/rtc/: rtc.c
    ../app/touch/: touch.c spi.c flash.c
    ../app/gui/: gui.c
  group awtk
    ../awtk/src/base/: bitmap.c canvas.c dialog.c enums.c font.c font_manager.c image_manager.c lcd.c main_loop.c theme.c widget.c widget_vtable.c window.c window_manager.c events.c timer.c layout.c event_queue.c window_animator.c idle.c system_info.c image_loader.c velocity.c widget_factory.c input_method.c input_engine.c glyph_cache.c line_break.c suggest_words.c ui_builder.c vgcanvas.c widget_animator.c ui_loader.c assets_manager.c locale_info.c font_loader.c window_base.c widget_animator_factory_null.c style.c style_const.c style_factory.c widget_animator_manager.c clip_board.c image_base.c input_device_status.c children_layouter.c self_layouter.c lcd_profile.c window_animator_factory.c dialog_highlighter.c dialog_highlighter_factory.c children_layouter_factory.c self_layouter_factory.c shortcut.c style_mutable.c text_edit.c hscrollable.c native_window.c ui_feedback.c
    ../awtk/src/tkc/: buffer.c color.c emitter.c mem.c rect.c utf8.c value.c wstr.c utils.c str.c tokenizer.c color_parser.c easing.c fs.c matrix.c rom_fs.c path.c time_now.c date_time.c func_call_parser.c event.c named_value.c object.c object_default.c timer_info.c timer_manager.c idle_manager.c idle_info.c slist.c darray.c expr_eval.c int_str.c str_str.c
    ../awtk/src/widgets/: button.c check_button.c group_box.c image.c label.c progress_bar.c slider.c pages.c edit.c view.c spin_box.c dragger.c dialog_client.c dialog_title.c button_group.c combo_box.c combo_box_item.c popup.c tab_button.c tab_button_group.c tab_control.c color_tile.c app_bar.c column.c grid.c row.c calibration_win.c grid_item.c system_bar.c overlay.c dialog_helper.c widgets.c
    ../awtk/src/main_loop/: main_loop_simple.c
    ../awtk/src/input_engines/: input_engine_null.c
    ../awtk/src/: awtk_global.c
    ../awtk/src/input_methods/: input_method_creator.c
    ../awtk/src/ui_loader/: ui_binary_writer.c ui_builder_default.c ui_loader_default.c ui_loader_xml.c ui_serializer.c ui_xml_writer.c window_open.c
    ../awtk/src/xml/: xml_builder.c xml_parser.c
    ../awtk/src/font_loader/: font_loader_bitmap.c
    ../awtk/src/clip_board/: clip_board_default.c
    ../awtk/src/layouters/: children_layouter_default.c self_layouter_default.c children_layouter_builtins.c children_layouter_parser.c self_layouter_builtins.c self_layouter_parser.c self_layouter_menu.c
    ../awtk/src/native_window/: native_window_raw.c
    ../awtk/src/window_manager/: window_manager_default.c
    ../awtk/3rd/libunibreak/: wordbreak.c unibreakdef.c unibreakbase.c linebreakdef.c linebreakdata.c linebreak.c graphemebreak.c emojidef.c
  group awtk-port
    ../awtk-port/: lcd_stm32_raw.c main_loop_stm32_raw.c platform.c
    ../awtk/src/platforms/raw/: fs_os.c
    ../awtk/src/platforms/tos/: mutex.c sys_tick.c thread.c cond_var.c
  group awtk-demo
    ../awtk/demos/: demo_main.c demo1_app.c assets-mini.c
  group tencentos
    ../TencentOS/kernel/core/: tos_event.c tos_fifo.c tos_global.c tos_mmblk.c tos_mmheap.c tos_msg.c tos_mutex.c tos_pend.c tos_queue.c tos_robin.c tos_sched.c tos_sem.c tos_sys.c tos_task.c tos_tick.c tos_time.c tos_timer.c
    ../TencentOS/kernel/pm/: tos_pm.c tos_tickless.c
    ../TencentOS/arch/arm/arm-v7m/cortex-m3/armcc/: port_c.c port_s.S
    ../TencentOS/arch/arm/arm-v7m/common/: tos_cpu.c tos_fault.c
